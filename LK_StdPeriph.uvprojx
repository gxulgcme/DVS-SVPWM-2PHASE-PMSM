# Keil uVision project LK_StdPeriph.uvprojx, settings and files
target Linko 03x Project (6230000::V6.23::ARMCLANG)
  device: LKS32MC038Y6P8 Linko
  pack: Linko.LKS03x.1.1.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LKS_MC_Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wimplicit-function-declaration
  c include: .\User;.\StdPeriph;C:\Users\Administrator\AppData\Local\Arm\Packs\ARM\CMSIS\6.2.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group StdPeriph
    ./StdPeriph/: lks32mc03x_adc.c lks32mc03x_gpio.c lks32mc03x_MCPWM.c lks32mc03x_sys.c lks32mc03x_timer.c startup_lks32mc03x.s lks32mc03x_cmp.c lks32mc03x_dac.c lks32mc03x_uart.c lks32mc03x_nvr.lib
  group User
    ./User/: App2Core.c main.c MC_math.c hardware_init.c Global_Variable.c interrupt.c System_Init.c VFControlDriver.c IQ_math.c UsartTransmitLib.c
